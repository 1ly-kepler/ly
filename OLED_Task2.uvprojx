# Keil uVision project OLED_Task2.uvprojx, settings and files
target OLED_Task2 (6210000::V6.21::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: OLED_Task2 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c misc: -Oz -Wno-unsafe-buffer-usage -Wno-padded -Wno-cast-qual -Wno-missing-variable-declarations -Wno-implicit-int-conversion -Wno-missing-noreturn -Wno-switch-enum -Wno-covered-switch-default -Wno-sign-conversion -Wno-missing-prototypes -Wno-overlength-strings -Wno-missing-braces -Wno-invalid-utf8 -Wno-newline-eof -Wno-declaration-after-statement -Wno-implicit-fallthrough
  c include: ../Core/Inc;../u8g2;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include
  asm misc: -Wno-unsafe-buffer-usage -Wno-padded -Wno-cast-qual -Wno-missing-variable-declarations -Wno-implicit-int-conversion -Wno-missing-noreturn -Wno-switch-enum -Wno-covered-switch-default -Wno-sign-conversion -Wno-missing-prototypes -Wno-overlength-strings -Wno-missing-braces -Wno-invalid-utf8 -Wno-newline-eof -Wno-declaration-after-statement -Wno-implicit-fallthrough
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c u8g2_hal.c stm32f1xx_it.c stm32f1xx_hal_msp.c
    ../Core/Inc/: cn_font.h u8g2_hal.h
  group U8G2
    ../u8g2/: u8x8_d_ssd1306_128x64_noname.c u8x8_cad.c u8x8_setup.c u8x8_message.c u8x8_u8toa.c u8x8_u16toa.c u8x8_string.c u8x8_display.c u8x8_8x8.c u8x8_fonts.c u8x8_byte.c u8x8_gpio.c u8x8_capture.c u8x8_selection_list.c u8x8_input_value.c u8x8_debounce.c u8g2_kerning.c u8g2_setup.c u8g2_d_setup.c u8g2_d_memory.c u8g2_buffer.c u8g2_font.c u8g2_bitmap.c u8g2_box.c u8g2_circle.c u8g2_cleardisplay.c u8g2_hvline.c u8g2_ll_hvline.c u8g2_line.c u8g2_intersection.c u8g2_polygon.c u8g2_font_6x10_tf.c u8g2_font_8x13_tf.c u8g2_font_10x20_tf.c u8g2.h u8x8.h
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
software components: CMSIS:CORE 4.3.0
